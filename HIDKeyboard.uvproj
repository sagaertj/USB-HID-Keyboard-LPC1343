# Keil uVision project HIDKeyboard.uvproj, settings and files
target LPC1343 Flash (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: hidkeyboard +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe  -v  --bin --output  $L@L.bin #L
  AfterMake: D:\Keil\makearmbin.bat $L@L.bin g
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup Files
    ./: startup_LPC13xx.s system_LPC13xx.c
  group Source Files
    ./: usbhw_LPC13xx.c usbcfg_LPC13xx.h usbcore.c usbdesc.c usbuser.c hiduser.c HIDKeyboard.c
